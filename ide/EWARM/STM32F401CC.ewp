# IAR project STM32F401CC.ewp, settings and files
configuration STM32F401CCU6 Blink Bare Metal (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401CC ST STM32F401CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F401xC
  ICCARM.CCIncludePath2: ..\..\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F401CC.hex
  ILINK.IlinkOutputFile: STM32F401CC.out
  ILINK.IlinkIcfFile: stm32f401xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group src
    ../../: main.c
    ./: startup_stm32f401xc.s
    ../../CMSIS/: system_stm32f4xx.c
