# Keil uVision project Project.uvprojx, settings and files
target STM32F401CCU6-Blink-Bare-Metal (6180000::V6.18::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=9 wLevel=2
  c define: STM32F401xC
  c misc: -Wpedantic -Wextra
  c include: ..\..\CMSIS\core;..\..\CMSIS\device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ../../: main.c crt0.c
    ../../CMSIS/device/: system_stm32f4xx.c
    ../../ide/MDK-ARM/: startup_stm32f401xc.s
software components: CMSIS:CORE 6.2.0
